<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>serial_port</key>
<param><key>id</key><value>serial_port_0</value></param>
<param><key>device</key><value>/dev/pts/5</value></param>
<param><key>stopbits</key><value>0</value></param>
<param><key>parity</key><value>0</value></param>
<param><key>bytesize</key><value>1</value></param>
<param><key>waitfornewline</key><value>False</value></param>
<param><key>baudrate</key><value>115200</value></param>
</block>
<block>
<key>serial_port</key>
<param><key>id</key><value>serial_port_0_0</value></param>
<param><key>device</key><value>/dev/pts/7</value></param>
<param><key>stopbits</key><value>0</value></param>
<param><key>parity</key><value>0</value></param>
<param><key>bytesize</key><value>1</value></param>
<param><key>waitfornewline</key><value>False</value></param>
<param><key>baudrate</key><value>115200</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>vsp_connect</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>serial_port_0_0</source_block_id><sink_block_id>serial_port_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>serial_port_0</source_block_id><sink_block_id>serial_port_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
